SYSTEMD_AUTO_ENABLE:${PN}-systemd = "enable"
